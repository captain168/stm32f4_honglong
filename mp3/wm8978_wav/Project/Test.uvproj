# Keil uVision project Test.uvproj, settings and files
target Test (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Test +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HAVE_CONFIG_H,DEBUG,OPT_SPEED,FPM_DEFAULT,STDC_HEADERS
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\BaseDrive;..\ExternalDrive\lcd;..\ExternalDrive\I2C;..\ExternalDrive\radio;..\ExternalDrive\TEA5767;..\ExternalDrive\wm8978;..\ExternalDrive\Button;..\ExternalDrive\Button\Fonts;..\ExternalDrive\SDCARD;..\ExternalDrive\FATS;..\ExternalDrive\WAV;..\ExternalDrive\I2S;..\libmad-0.15.1b;..\libmad-0.15.1b\msvc++
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../User/: system_stm32f4xx.c startup_stm32f4xx.s
  group User
    ../User/: main.c stm32f4xx_it.c
  group Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_pwr.c stm32f4xx_spi.c
  group F4Lib
    ../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group BaseDrive
    ../BaseDrive/: Gpio.c SysTick.c Uart.c
  group Doc
    ../Doc/: ReadMe.txt
  group ExternalDrive\I2C
    ../ExternalDrive/I2C/: i2c_gpio.c
  group ExternalDrive\radio
    ../ExternalDrive/radio/: fm_radio.c
  group ExternalDrive\TEA5767
    ../ExternalDrive/TEA5767/: bsp_TEA5767.c
  group ExternalDrive\wm8978
    ../ExternalDrive/wm8978/: bsp_WM8978.c
  group ExternalDrive\Button
    ../ExternalDrive/Button/: button.c tft_lcd.c
  group ExternalDrive\fat
    ../ExternalDrive/Button/Fonts/: ASC16.c HzLib.c
  group ExternalDrive\SDIO
    ../ExternalDrive/SDCARD/: sdio_sd.c
  group ExternalDrive\Fatfs
    ../ExternalDrive/FATS/: ccsbcs.c diskio.c ff.c
  group ExternalDrive\WAV
    ../ExternalDrive/WAV/: wav.c
  group ExternalDrive\iis
    ../ExternalDrive/I2S/: I2S.c
  group libmad-0.15.1b
    ../libmad-0.15.1b/: bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c minimad.c stream.c synth.c timer.c
  group madlld-1.1p1
    ../madlld-1.1p1/: bstdfile.c madlld.c
