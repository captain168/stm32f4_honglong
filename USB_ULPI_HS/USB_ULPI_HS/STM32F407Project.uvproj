# Keil uVision project STM32F407Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F407Project +hex
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: .\Source;.\Source\inc;.\Source\USB_App;.\Source\Core\inc;.\Source\Class\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s
  group AppFile
    ./Source/: main.c STM32F4_UART.c stm32f4xx_it.c system_stm32f4xx.c SysTick.c udisk.c
  group STM32F407File
    ./Source/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c
  group USB_App
    ./Source/USB_App/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USB_Driver
    ./Source/Core/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ./Source/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./Source/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group Doc
    ./: Readme.txt
